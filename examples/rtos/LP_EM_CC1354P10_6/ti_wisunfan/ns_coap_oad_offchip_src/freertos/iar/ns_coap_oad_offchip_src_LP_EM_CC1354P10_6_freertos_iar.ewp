# IAR project ns_coap_oad_offchip_src_LP_EM_CC1354P10_6_freertos_iar.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  postbuild: ielftool --ihex --verbose "$TARGET_BPATH$.out" "$TARGET_BPATH$.hex" & ielftool --bin --verbose "$TARGET_BPATH$.out" $TARGET_BPATH$-noheader.bin & $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/tools/common/mcuboot/imgtool sign --header-size 0x80 --align 4 --slot-size 0x56000 --pad --version 1.0.0 --pad-header --key $COM_TI_SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/third_party/mcuboot/root-ec-p256.pem $TARGET_BPATH$-noheader.bin $TARGET_BPATH$.bin
  group (top)
    ./: ns_coap_oad_offchip_src_LP_EM_CC1354P10_6_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
